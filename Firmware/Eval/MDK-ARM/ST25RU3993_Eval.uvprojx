# Keil uVision project ST25RU3993_Eval.uvprojx, settings and files
target ST25RU3993_Eval (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: ST25RU3993_Eval +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output=..\..\ST25RU3993_Eval.bin ST25RU3993_Eval\ST25RU3993_Eval.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx,EVAL=1,FAST_UART=1,STUHFL_HOST_COMMUNICATION=1
  c include: ../Inc; ../../Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; ../../../middleware/clib/STUHFL/inc; ../../../middleware/clib/STUHFL/inc/platform
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xff000
  memory RVCT9: RAM 0x20000000 size 0x17ff0
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/ST25RU3993
    ../../Src/: uart_stream_driver.c adc_driver.c evalAPI_commands.c bitbang.c bootloader.c crc.c flash_access.c gen2.c global.c logger.c platform.c spi_driver.c st25RU3993.c stream_dispatcher.c timer.c tuner.c uart_driver.c gb29768.c
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c
  group Middleware/STUHFL
    ../../../middleware/clib/STUHFL/src/: stuhfl_helpers.c
  group Application/User
    ../Src/: main.c gpio.c adc.c dma.c rtc.c spi.c tim.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c
software components: CMSIS:CORE 4.3.0
